V_Source $N_0000 $N_0001 1.00 93 100 1
L_inductor $N_0003 $N_0001 1.00m 252 46 0
C_cap $N_0000 $N_0002 5.00u 132 45 0
R_Res $N_0002 $N_0003 10.00 176 45 0
